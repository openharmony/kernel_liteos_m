# Keil uVision project los_demo.uvproj, settings and files
target los_demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: los_demo
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c misc: --gnu
  c include: ..\..\cortex-m3_stm32f103_simulator_keil;..\..\..\kernel\include;..\..\..\kernel\arch\arm\cortex-m3\keil;..\..\..\kernel\arch\arm\cortex-m3\keil\cmsis;..\..\..\kernel\src;..\..\..\components\bounds_checking_function\include;..\..\..\components\cpup;..\..\..\utils;..\..\..\kernel\arch\include;..\..\..\components\exchook
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x500000
  scatter file: .\los_demo.sct
  group liteos-m
    ../../../kernel/src/: los_event.c los_init.c los_mux.c los_queue.c los_sem.c los_swtmr.c los_task.c los_tick.c
    ../../../kernel/src/mm/: los_membox.c los_memory.c
    ../../../kernel/arch/arm/cortex-m3/keil/: los_dispatch.S los_interrupt.c los_context.c los_timer.c los_exc.S los_startup.s
    ../../../kernel/arch/arm/cortex-m3/keil/cmsis/: ARMCM3.h core_cm3.h core_cmFunc.h core_cmInstr.h
    ../../../components/cpup/: los_cpup.c
    ../../../utils/: los_error.c los_debug.c
  group main
    ../Driver/STM32F103/: uart.c
    ../: main.c target_config.h
  group component
    ../../../components/bounds_checking_function/src/: memcpy_s.c memmove_s.c memset_s.c strcpy_s.c strncpy_s.c
    ../../../components/exchook/: los_exc_info.c los_exc_info.h los_exchook.c los_exchook.h
